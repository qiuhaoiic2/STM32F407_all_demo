# Keil uVision project stm32f407.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\Version_5)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,NDEBUG,LV_CONF_INCLUDE_SIMPLE
  c include: ..\app\inc;..\driver\led;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\driver\uart;..\third_lib\letter_shell;..\third_lib\ringbuff;..\third_lib\tlsf;..\driver\timer;..\driver\dht11;..\driver\lcd;..\third_lib\FreeRTOS\include;..\third_lib\FreeRTOS\portable\RVDS\ARM_CM4F;..\third_lib\lvgl;..\third_lib\easy_logger
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c board.c user_lvgl.c
  group app/shell
    ../app/: mem_megnt.c
    ../app/command/: shell_command.c
  group driver
    ../driver/led/: led.c
    ../driver/uart/: uart.c
    ../driver/timer/: delay.c
    ../driver/dht11/: dht11.c
    ../driver/lcd/: lcd.c
  group firmware
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx.c
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib/shell
    ../third_lib/letter_shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
  group third_lib/ringbuff
    ../third_lib/ringbuff/: ringbuffer8.c
  group third_lib/tlsf
    ../third_lib/tlsf/: tlsf.c
  group third_lib/FreeRTOS
    ../third_lib/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../third_lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../third_lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group third_lib/lvgl
    ../third_lib/lvgl/src/: lv_init.c
    ../third_lib/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../third_lib/lvgl/src/display/: lv_display.c
    ../third_lib/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../third_lib/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../third_lib/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../third_lib/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../third_lib/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../third_lib/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../third_lib/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
    ../third_lib/lvgl/src/layouts/flex/: lv_flex.c
    ../third_lib/lvgl/src/layouts/grid/: lv_grid.c
    ../third_lib/lvgl/src/layouts/: lv_layout.c
    ../third_lib/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
    ../third_lib/lvgl/src/misc/cache/: _lv_cache_lru_rb.c lv_cache.c lv_cache_entry.c lv_image_cache.c
    ../third_lib/lvgl/src/osal/: lv_freertos.c
    ../third_lib/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../third_lib/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../third_lib/lvgl/src/stdlib/: lv_mem.c
    ../third_lib/lvgl/src/themes/: lv_theme.c
    ../third_lib/lvgl/src/themes/default/: lv_theme_default.c
    ../third_lib/lvgl/src/themes/simple/: lv_theme_simple.c
    ../third_lib/lvgl/src/themes/mono/: lv_theme_mono.c
    ../third_lib/lvgl/src/tick/: lv_tick.c
    ../third_lib/lvgl/src/widgets/animimage/: lv_animimage.c
    ../third_lib/lvgl/src/widgets/arc/: lv_arc.c
    ../third_lib/lvgl/src/widgets/bar/: lv_bar.c
    ../third_lib/lvgl/src/widgets/button/: lv_button.c
    ../third_lib/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../third_lib/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../third_lib/lvgl/src/widgets/canvas/: lv_canvas.c
    ../third_lib/lvgl/src/widgets/chart/: lv_chart.c
    ../third_lib/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../third_lib/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../third_lib/lvgl/src/widgets/image/: lv_image.c
    ../third_lib/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../third_lib/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../third_lib/lvgl/src/widgets/label/: lv_label.c
    ../third_lib/lvgl/src/widgets/led/: lv_led.c
    ../third_lib/lvgl/src/widgets/line/: lv_line.c
    ../third_lib/lvgl/src/widgets/list/: lv_list.c
    ../third_lib/lvgl/src/widgets/menu/: lv_menu.c
    ../third_lib/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../third_lib/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../third_lib/lvgl/src/widgets/win/: lv_win.c
    ../third_lib/lvgl/src/widgets/tileview/: lv_tileview.c
    ../third_lib/lvgl/src/widgets/textarea/: lv_textarea.c
    ../third_lib/lvgl/src/widgets/table/: lv_table.c
    ../third_lib/lvgl/src/widgets/switch/: lv_switch.c
    ../third_lib/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group third_lib/lvgl/config
    ../third_lib/lvgl/: lv_conf.h lvgl.h
  group third_lib/easy_log
    ../third_lib/easy_logger/: elog.c elog_async.c elog_buf.c elog_port.c elog_utils.c
